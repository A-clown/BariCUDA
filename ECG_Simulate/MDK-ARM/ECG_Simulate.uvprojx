# Keil uVision project ECG_Simulate.uvprojx, settings and files
target ECG_Simulate (ARM-ADS)
  device: STM32H750VBTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x08000000-0x0807FFFF) CPUTYPE("Cortex-M7") FPU2 CLOCK(21600000)
  output: ECG_Simulate +hex
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ..\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Drivers\STM32H7xx_HAL_Driver\Inc
  group Application
    ../Core/Src/: main.c ecg.c usart1.c
  group HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_uart.c
